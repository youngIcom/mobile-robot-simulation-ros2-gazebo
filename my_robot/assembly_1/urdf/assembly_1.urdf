Commit message: Fix rviz for robot 2 final

File: my_robot/assembly_1/urdf/assembly_1.urdf (robot description, URDF)
Before this commit: robot assembly_1, 123 links, 122 joints
Joints:
- joint fixed_node_to_root_joint_89: type continuous -> fixed
